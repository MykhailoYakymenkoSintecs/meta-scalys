# As Grapeboard is compatible with ls1012ardb it is 
# simplier to just use ardb's config instead of applying patches

OPTEEMACHINE:trustbox-edge-101 = "ls-ls1012ardb"

